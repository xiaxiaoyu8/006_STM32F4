# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\Drivers\CMSIS;.\Middleware;.\User;.\Drivers\BSP;.\Drivers\SYS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers/CMSIS
    ./Drivers/CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group Drivers/SYS
    ./Drivers/SYS/: system.c system.h
  group User
    ./User/: main.c
