# Keil uVision project Template.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./Startup/: startup_stm32f407xx.s
  group Drivers/BSP
    ./Drivers/BSP/: Delay.c Delay.h led.c led.h
  group Drivers/SYSTEM
    ./Drivers/SYSTEM/: delay.c delay.h sys.c sys.h usart.c usart.h
  group Drivers/CMSIS
    ./Drivers/CMSIS/: core_cm4.h stm32f4xx.h stm32f407xx.h
  group User
    ./User/: main.c stm32f4xx_it.c system_stm32f4xx.c
